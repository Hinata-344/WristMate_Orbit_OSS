# Repository Hinata-344/WristMate_Orbit_OSS

File README.md:

# WristMate_Orbit

画面を持たない自作スマートウォッチ。外周60個と7セグ4桁などのLED(計92個)と振動だけで表示し、ダイヤル(ロータリーエンコーダ)1つと腕の動きで操作する。

## 中身

```
firmware/WristMate_Orbit/   Arduino スケッチ(本体)
hardware/v5_XIAO-ESP32S3_Encoder/  基板 v5(現行)。マイコンは Seeed XIAO ESP32-S3、ロータリーエンコーダ付き
hardware/v4_ESP32-C3-SuperMini/  基板 v4(旧版)。マイコンは ESP32-C3 SuperMini
```

各 `hardware/` には KiCad プロジェクト(`.kicad_pro` / `.kicad_sch` / `.kicad_pcb`)が入っている。v4 には JLCPCB 発注用のガーバー・BOM・CPL(`jlcpcb/`)もある。v5 のガーバーは KiCad から出力する。

**現行のファームウェアは v5(XIAO ESP32-S3)用。** v4 基板ではピン割り当てが違うのでそのままでは動かない。

## 主な機能

- 時計・歩数・ポモドーロ・カウンター・タイマー
- 電車の発車までの残り時間(サブLEDの色で、間に合うかが分かる)
- モールス符号の練習(光と振動)、ライト(16段階調光)、SOS点滅
- 手首を上げると点灯・下ろすと消灯、転倒検知(起きている間 / スリープ中)
- 居眠り防止(ディープスリープのまま定期的に動きを確認)
- BLE キーボード/マウス: スライド送り、ショート動画送り、カメラのシャッター
- ゲーム4種(擬似重力・金庫破り・モグラ叩き・ハイ&ロー)
- スマホのブラウザから設定(Wi-Fi の設定画面。アプリ不要)

メニューは `WristMate_Orbit.ino` の `MENU_LIST` から作られる。1行足して動作を書けば、機能を追加できる。

## ハードウェア(v5)

| 部品 | 役割 |
|---|---|
| Seeed XIAO ESP32-S3 | マイコン |
| IS31FL3733 | LED ドライバ(I2C) |
| BMA400 | 加速度センサー(手首起床・歩数・タップ・転倒) |
| RV-3028 | RTC |
| ロータリーエンコーダ(押しボタン付き) | 操作 |
| 振動モーター / COB LED / CdS | 振動・ライト・明るさ検知 |

ピン: D0=加速度 INT1, D1=COB, D2=LED ドライバ EN, D3=SDA, D4=SCL, D5=振動, D6/D7=エンコーダ A/B, D8=CdS, D9=RTC INT, D10=スイッチ

## ビルド

- Arduino IDE または arduino-cli。ボード: `esp32:esp32:XIAO_ESP32S3`(Arduino-ESP32 3.x)
- 必要なライブラリ
  - ESP32Encoder
  - SparkFun BMA400 Arduino Library
- BLE キーボードは `src/HijelHID_BLEKeyboard/` に同梱(Apache-2.0。ライセンスは同フォルダの `LICENSE`)

```sh
arduino-cli compile -b esp32:esp32:XIAO_ESP32S3 firmware/WristMate_Orbit
```

## 設定画面

メニューの SETTING を開くと、時計が Wi-Fi の親機になる。スマホで接続するとブラウザに設定画面が出る。

- SSID: `WristMate-Orbit` / パスワード: `orbit1234`(`OrbitConfig.h` の `OC_AP_PASS`)。**自分用に作るときは変えること。**
- メニューの順番と表示、時刻表(駅A/駅Bの平日・休日)、スリープまでの時間、時刻合わせなどを変えられる。
- 内蔵の時刻表はサンプル。実際の時刻表は設定画面から貼り付ける。

## ライセンス

| 対象 | ライセンス |
|---|---|
| `firmware/`(プログラム) | [MIT](LICENSE) |
| `hardware/`(回路図・基板)、`docs/images/`(画像) | [CC BY 4.0](hardware/LICENSE) |
| `firmware/WristMate_Orbit/src/HijelHID_BLEKeyboard/` | Apache-2.0(同フォルダの `LICENSE`。元の作者のもの) |

自由に使い、改造し、配布してよい。その際は作者名(Hinata)とライセンスを表示すること。

© 2026 Hinata

## KiCad design hardware/v5_XIAO-ESP32S3_Encoder/WristMate_Orbit.kicad_pcb

Board: 2 copper layers, 40.0 x 40.0 mm, 10 parts (1 on the bottom side), 16 nets.

Parts:
D97: D; CHIP_R_SMD
ENC1: EC05E1220401
J7: Conn_01x11_Socket; 11pin_th_5_2pin
M1: Motor_DC; VibrationMotor
Q2: NPN; NPN_MMBT3904
R11: 1k; CHIP_C_SMD
R13: 10k; CHIP_C_SMD
U4: CDS
XIAO1: XIAO-ESP32-S3-SMD; XIAO-ESP32-S3_cutted_
draw: 8b95931c-af33-4c21-b8dc-b51557f3a42e

Connections:
+3.3VA: D97.1 (K), J7.3, M1.1 (+), R13.2, XIAO1.12 (3V3_OUT)
+5VA: J7.2, XIAO1.14 (VBUS)
BMA_INT1_base: J7.8, XIAO1.1 (D0)
CDS: R13.1, U4.1, XIAO1.9 (D8)
COB: J7.7, XIAO1.2 (D1)
ENC_A: ENC1.B, XIAO1.7 (D6)
ENC_B: ENC1.A, XIAO1.8 (D7)
GND3: ENC1.C, J7.1, Q2.3 (E), U4.2, XIAO1.13 (GND)
LED_DRIVER_en: J7.6, XIAO1.3 (D2)
unnamed: D97.2 (A), M1.2 (-), Q2.1 (C)
unnamed: Q2.2 (B), R11.1
RV_INT_base: J7.10, XIAO1.10 (D9)
SCL_base: J7.5, XIAO1.5 (D4)
SDA_base: J7.4, XIAO1.4 (D3)
SW: J7.11, XIAO1.11 (D10)
VIBE_DRV: R11.2, XIAO1.6 (D5)

## KiCad design hardware/v4_ESP32-C3-SuperMini/WristMate_Orbit.kicad_pcb

Parts:
BT1: Battery_Cell; 2Pin_Through_Hole_V2
C1, C2, C3, C4: 0.1uF; CHIP_C_small_SMD
C5: 10u; CHIP_C_SMD
C6, C7: 0.1μF; CHIP_C_small_SMD
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60: LED; LED_0805_over
D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D98, D99: LED; LED_0805
D91, D92, D93, D94: LED; COB_LED_Chip
D95: STDBY_LED; CHIP_LED_SMD
D96: CHRG_LED; CHIP_LED_SMD
D97: D; CHIP_R_SMD
J1: USB_C_Receptacle; USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_Horizontal
J2: Conn_01x05_Socket; 6pin_pad
J3: Conn_01x05_Socket; 6pin_pad_mount_hole
J4: mameDenchi3v; SR416SW_2
J5: RTC_rv3028; RV-3028-C7
J6, J7: Conn_01x11_Socket; 11pin_th_5_2pin
M1: Motor_DC; VibrationMotor
Q1, Q3: PNP; SOT23-BEC
Q2: NPN; NPN_MMBT3904
R1: 390; CHIP_C_SMD
R2, R3: 5.1k; CHIP_C_SMD
R4, R7, R13: 10k; CHIP_C_SMD
R5, R11, R18: 1k; CHIP_C_SMD
R6, R8, R9, R10, R12: 1kR; CHIP_C_SMD
R14: 100R; CHIP_C_SMD
R15, R16: 4.7k; CHIP_C_SMD
R17: 1kΩ; CHIP_C_SMD
SW1, SW2: slide_sw
SW3: SW_Push; SW_Silent
SuperMini1: SuperMini_cutted_
U1: IS31FL3733-QF; QFN-48-1EP_6x6mm_P0.4mm_EP4.2x4.2mm
U2: TP4056_SMD
U3: DW01A
U4: CDS
U5: FS8205A
U6: BMA400; XDCR_BMA400

Connections:
+3.3V: C6.1, J5.7, J6.3, Q3.3 (E), R15.2, R16.2, U6.3 (VDDIO), U6.7 (VDD), U6.10 (~CSB)
+3.3VA: D97.1 (K), J7.3, M1.1 (+), R13.2, SuperMini1.6 (3.3)
+5V: J6.2, Q1.3 (E), SW1.1
+5VA: J7.2, SuperMini1.8 (5V)
BAT+: BT1.1 (+), C5.1, R14.2, SW1.2, U2.5 (BAT)
BAT-: BT1.2 (-), C4.2, U3.6 (GND), U5.2 (S1), U5.3 (S1)
BMA_INT1: J6.8, U6.5 (INT1)
BMA_INT1_base: J7.8, SuperMini1.9 (5)
BMA_INT2: J6.9, U6.6 (INT2)
BMA_INT2_base: J7.9, SuperMini1.5 (4)
COB: J7.7, SuperMini1.10 (6)
CS1: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.16 (CS1)
CS2: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.17 (CS2)
CS3: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), U1.18 (CS3)
CS4: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), U1.19 (CS4)
CS5: D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), U1.21 (CS5)
CS6: D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D65.1 (K), U1.22 (CS6)
CS7: D66.1 (K), D67.1 (K), D68.1 (K), D69.1 (K), D70.1 (K), U1.23 (CS7)
CS8: D71.1 (K), D72.1 (K), D73.1 (K), D74.1 (K), D98.1 (K), U1.24 (CS8)
CS9: D75.1 (K), D76.1 (K), D77.1 (K), D78.1 (K), D99.1 (K), U1.25 (CS9)
CS10: D79.1 (K), D80.1 (K), D81.1 (K), D82.1 (K), U1.26 (CS10)
CS11: D83.1 (K), D84.1 (K), D85.1 (K), D86.1 (K), U1.27 (CS11)
CS12: D87.1 (K), D88.1 (K), D89.1 (K), D90.1 (K), U1.28 (CS12)
GND2: C1.1, D91.1 (K), D92.1 (K), D93.1 (K), D94.1 (K), J2.1, R7.2, U1.5 (PGND), U1.12 (PGND), U1.34 (AGND), U1.40 (SYNC), U1.43 (ADDR1), U1.44 (ADDR2), U1.47 (IICRST), U1.48 (GND), U1.49 (GND)
GND3: J7.1, Q2.3 (E), SuperMini1.7 (GND), U4.2
LED_DRIVER_en: J7.6, SuperMini1.11 (7)
unnamed: D91.2 (A), D92.2 (A), D93.2 (A), D94.2 (A), J2.2
unnamed: D95.1 (K), R6.1
unnamed: D96.1 (K), R8.1
unnamed: D97.2 (A), M1.2 (-), Q2.1 (C)
unnamed: J1.A5 (CC1), R3.1
unnamed: J1.B5 (CC2), R2.1
unnamed: C1.2, J2.3, U1.20 (PVCC), U1.29 (PVCC), U1.37 (AVCC), U1.38 (DVCC), U1.39 (VIO), U1.46 (~SDB)
unnamed: J2.4, U1.41 (SDA)
unnamed: J2.5, U1.42 (SCL)
unnamed: J3.2, R1.1
unnamed: J3.3, Q3.1 (C)
unnamed: C7.1, J4.1, R17.1
unnamed: J5.6, R17.2
unnamed: J6.6, R18.1
unnamed: J6.7, R5.1, SW2.1
unnamed: J6.11, SW3.1
unnamed: Q1.2 (B), R5.2
unnamed: Q1.1 (C), R1.2
unnamed: Q2.2 (B), R11.1
unnamed: Q3.2 (B), R18.2
unnamed: R4.2, R7.1
unnamed: R9.2, R10.1
unnamed: R13.1, SuperMini1.2 (1), U4.1
unnamed: R11.2, SuperMini1.14 (10)
unnamed: R4.1, U1.35 (RSET)
unnamed: R8.2, U2.7 (CHRG)
unnamed: R9.1, U2.2 (PRDG)
unnamed: R6.2, U2.6 (STDBY)
unnamed: R12.2, U3.2 (CS)
unnamed: U3.3 (OC), U5.5 (G2)
unnamed: U3.1 (OD), U5.4 (G1)
unnamed: C4.1, R14.1, U3.5 (VCC)
RV_INT: J5.2, J6.10
RV_INT_base: J7.10, SuperMini1.4 (3)
SCL: J3.5, J5.3, J6.5, R16.1, U6.12 (SCX)
SCL_base: J7.5, SuperMini1.13 (9)
SDA: J3.4, J5.4, J6.4, R15.1, U6.2 (SDX)
SDA_base: J7.4, SuperMini1.12 (8)
SW: J7.11, SuperMini1.1 (0)
SW1: D1.2 (A), D13.2 (A), D25.2 (A), D37.2 (A), D49.2 (A), D61.2 (A), D66.2 (A), D71.2 (A), D75.2 (A), D79.2 (A), D83.2 (A), D87.2 (A), U1.2 (SW1)
SW2: D2.2 (A), D14.2 (A), D26.2 (A), D38.2 (A), D50.2 (A), D62.2 (A), D67.2 (A), D72.2 (A), D76.2 (A), D80.2 (A), D84.2 (A), D88.2 (A), U1.3 (SW2)
SW3: D3.2 (A), D15.2 (A), D27.2 (A), D39.2 (A), D51.2 (A), D63.2 (A), D68.2 (A), D73.2 (A), D77.2 (A), D81.2 (A), D85.2 (A), D89.2 (A), U1.4 (SW3)
SW4: D4.2 (A), D16.2 (A), D28.2 (A), D40.2 (A), D52.2 (A), D64.2 (A), D69.2 (A), D74.2 (A), D78.2 (A), D82.2 (A), D86.2 (A), D90.2 (A), U1.6 (SW4)
SW5: D5.2 (A), D17.2 (A), D29.2 (A), D41.2 (A), D53.2 (A), D65.2 (A), D70.2 (A), D98.2 (A), D99.2 (A), U1.7 (SW5)
SW6: D6.2 (A), D18.2 (A), D30.2 (A), D42.2 (A), D54.2 (A), U1.8 (SW6)
SW7: D7.2 (A), D19.2 (A), D31.2 (A), D43.2 (A), D55.2 (A), U1.9 (SW7)
SW8: D8.2 (A), D20.2 (A), D32.2 (A), D44.2 (A), D56.2 (A), U1.10 (SW8)
SW9: D9.2 (A), D21.2 (A), D33.2 (A), D45.2 (A), D57.2 (A), U1.11 (SW9)
SW10: D10.2 (A), D22.2 (A), D34.2 (A), D46.2 (A), D58.2 (A), U1.13 (SW10)
SW11: D11.2 (A), D23.2 (A), D35.2 (A), D47.2 (A), D59.2 (A), U1.14 (SW11)
SW12: D12.2 (A), D24.2 (A), D36.2 (A), D48.2 (A), D60.2 (A), U1.15 (SW12)
VCC: C2.1, C3.1, D95.2 (A), D96.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U2.4 (VCC), U2.8 (CE)
VOUT-: C2.2, C3.2, C5.2, C6.2, C7.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J3.1, J4.2, J5.5, J5.8, J6.1, R2.2, R3.2, R10.2, R12.1, SW2.2, SW3.2, U2.1 (TEMP), U2.3 (GND), U2.9 (EP), U5.6 (S2), U5.7 (S2), U6.1 (SDO), U6.8 (GNDIO), U6.9 (GND)

Notes on the sheet:
sdbをhighに繋ぐ
TP4056
BMA400
ccpin 見直そ！
RTC

Board: 2 copper layers, 100.0 x 100.0 mm, 146 parts (2 on the bottom side), 79 nets.

Other parts of the board:
draw: 8b95931c-af33-4c21-b8dc-b51557f3a42e

File hardware/v4_ESP32-C3-SuperMini/jlcpcb/production_files/BOM-WristMate_Orbit.csv:

Comment,Designator,Footprint,LCSC,Quantity
LED,D98,LED_0805,,1
LED,D99,LED_0805,,1
~,SW1,slide_sw,,1
LED,D87,LED_0805,,1
LED,D84,LED_0805,,1
Motor_DC,M1,VibrationMotor,,1
5.1k,R3,CHIP_C_SMD,,1
LED,D63,LED_0805,,1
Battery_Cell,BT1,2Pin_Through_Hole_V2,,1
1kR,R8,CHIP_C_SMD,,1
CHRG_LED,D96,CHIP_LED_SMD,,1
LED,D22,LED_0805_over,,1
LED,D54,LED_0805_over,,1
LED,D36,LED_0805_over,,1
LED,D23,LED_0805_over,,1
LED,D56,LED_0805_over,,1
~,U2,TP4056_SMD,,1
1kR,R9,CHIP_C_SMD,,1
LED,D37,LED_0805_over,,1
LED,D58,LED_0805_over,,1
390,R1,CHIP_C_SMD,,1
mameDenchi3v,J4,SR416SW_2,,1
10k,R13,CHIP_C_SMD,,1
LED,D20,LED_0805_over,,1
watch_mount,REF**,watch_mount,,1
Conn_01x11_Socket,J6,11pin_th_5_2pin,,1
0.1μF,C6,CHIP_C_small_SMD,,1
0.1μF,C7,CHIP_C_small_SMD,,1
LED,D82,LED_0805,,1
LED,D35,LED_0805_over,,1
LED,D9,LED_0805_over,,1
LED,D13,LED_0805_over,,1
LED,D70,LED_0805,,1
LED,D86,LED_0805,,1
BMA400,U6,XDCR_BMA400,,1
4.7k,R16,CHIP_C_SMD,,1
1kR,R6,CHIP_C_SMD,,1
STDBY_LED,D95,CHIP_LED_SMD,,1
LED,D53,LED_0805_over,,1
LED,D72,LED_0805,,1
LED,D49,LED_0805_over,,1
LED,D66,LED_0805,,1
LED,D62,LED_0805,,1
1kR,R10,CHIP_C_SMD,,1
LED,D88,LED_0805,,1
LED,D94,COB_LED_Chip,,1
LED,D90,LED_0805,,1
SW_Push,SW3,SW_Silent,,1
LED,D32,LED_0805_over,,1
LED,D29,LED_0805_over,,1
LED,D81,LED_0805,,1
LED,D59,LED_0805_over,,1
LED,D5,LED_0805_over,,1
4.7k,R15,CHIP_C_SMD,,1
LED,D55,LED_0805_over,,1
LED,D80,LED_0805,,1
LED,D60,LED_0805_over,,1
100R,R14,CHIP_C_SMD,,1
10k,R7,CHIP_C_SMD,,1
PNP,Q3,SOT23-BEC,,1
LED,D11,LED_0805_over,,1
1kR,R12,CHIP_C_SMD,,1
1k,R18,CHIP_C_SMD,,1
LED,D76,LED_0805,,1
LED,D1,LED_0805_over,,1
LED,D31,LED_0805_over,,1
1kΩ,R17,CHIP_C_SMD,,1
LED,D65,LED_0805,,1
LED,D61,LED_0805,,1
LED,D44,LED_0805_over,,1
LED,D41,LED_0805_over,,1
LED,D6,LED_0805_over,,1
LED,D17,LED_0805_over,,1
RTC_rv3028,J5,RV-3028-C7,,1
LED,D52,LED_0805_over,,1
LED,D30,LED_0805_over,,1
~,SW2,slide_sw,,1
LED,D10,LED_0805_over,,1
NPN,Q2,NPN_MMBT3904,,1
LED,D71,LED_0805,,1
LED,D67,LED_0805,,1
LED,D27,LED_0805_over,,1
5.1k,R2,CHIP_C_SMD,,1
LED,D7,LED_0805_over,,1
LED,D57,LED_0805_over,,1
LED,D75,LED_0805,,1
LED,D15,LED_0805_over,,1
LED,D4,LED_0805_over,,1
LED,D46,LED_0805_over,,1
LED,D47,LED_0805_over,,1
~,U5,FS8205A,,1
1k,R5,CHIP_C_SMD,,1
LED,D39,LED_0805_over,,1
0.1uF,C1,CHIP_C_small_SMD,,1
Conn_01x05_Socket,J3,6pin_pad_mount_hole,,1
LED,D43,LED_0805_over,,1
LED,D78,LED_0805,,1
LED,D18,LED_0805_over,,1
LED,D83,LED_0805,,1
LED,D77,LED_0805,,1
LED,D64,LED_0805,,1
LED,D8,LED_0805_over,,1
LED,D2,LED_0805_over,,1
LED,D51,LED_0805_over,,1
LED,D38,LED_0805_over,,1
LED,D16,LED_0805_over,,1
LED,D3,LED_0805_over,,1
LED,D40,LED_0805_over,,1
LED,D74,LED_0805,,1
0.1uF,C3,CHIP_C_small_SMD,,1
1k,R11,CHIP_C_SMD,,1
LED,D12,LED_0805_over,,1
LED,D24,LED_0805_over,,1
LED,D21,LED_0805_over,,1
LED,D33,LED_0805_over,,1
LED,D34,LED_0805_over,,1
LED,D42,LED_0805_over,,1
LED,D73,LED_0805,,1
LED,D45,LED_0805_over,,1
LED,D48,LED_0805_over,,1
PNP,Q1,SOT23-BEC,,1
0.1uF,C2,CHIP_C_small_SMD,,1
LED,D93,COB_LED_Chip,,1
LED,D79,LED_0805,,1
10u,C5,CHIP_C_SMD,,1
LED,D85,LED_0805,,1
LED,D89,LED_0805,,1
0.1uF,C4,CHIP_C_small_SMD,,1
D,D97,CHIP_R_SMD,,1
~,U4,CDS,,1
LED,D26,LED_0805_over,,1
10k,R4,CHIP_C_SMD,,1
LED,D50,LED_0805_over,,1
USB_C_Receptacle,J1,USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_Horizontal,,1
LED,D19,LED_0805_over,,1
LED,D68,LED_0805,,1
LED,D28,LED_0805_over,,1
,draw,8b95931c-af33-4c21-b8dc-b51557f3a42e,,1
LED,D14,LED_0805_over,,1
LED,D69,LED_0805,,1
~,U3,DW01A,,1
LED,D25,LED_0805_over,,1
Conn_01x11_Socket,J7,11pin_th_5_2pin,,1
Conn_01x05_Socket,J2,6pin_pad,,1
IS31FL3733-QF,U1,QFN-48-1EP_6x6mm_P0.4mm_EP4.2x4.2mm,,1
LED,D91,COB_LED_Chip,,1

## Code that names these connections

File firmware/WristMate_Orbit/WristMate_Orbit.ino (part):

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// §: Pins
// XIAO ESP32-S3 (D0=GPIO1, D1=GPIO2, D2=GPIO3, D3=GPIO4, D4=GPIO5, D5=GPIO6, D6=GPIO43, D7=GPIO44, D8=GPIO7, D9=GPIO8, D10=GPIO9)
const int SW_PIN = D10;
const int CDS_PIN = D8;
const int VIBES_PIN = D5; // high:ON, low:OFF
const int RTC_INT_PIN = D9;
const int LED_PIN = D1; // high:OFF, low:ON
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const int IS_EN_PIN = D2;
const int SDA_PIN = D3;
const int SCL_PIN = D4;
const int ENC_A_PIN = D6; // GPIO43: RTCピンではないのでエンコーダでは起床できない
const int ENC_B_PIN = D7; // GPIO44
const int SW_WAKE_PIN = SW_PIN;
unsigned long IDLE_DEEP_SLEEP_MS = 8000; // スリープ時間は設定画面で変更される
// const unsigned long IDLE_DEEP_SLEEP_MS = 600000;
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{
  long sum = 0;
  for (int i = 0; i < 16; i++)
    sum += analogRead(CDS_PIN);
  int raw = sum / 16;
  if (reset || cdsFiltered < 0)
    cdsFiltered = raw;
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  pinMode(SW_PIN, INPUT_PULLUP);
  encoderBegin();
  pinMode(RTC_INT_PIN, INPUT); // RV3028のINTはオープンドレイン、外部プルアップ前提
  digitalRead(CDS_PIN);
  delay(30); // IS31FL3733の電源立ち上がり待ち
  if (!ledcAttach(VIBES_PIN, PWM_FREQ, PWM_RESOLUTION))
  {
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void encoderBegin()
{
  ESP32Encoder::useInternalWeakPullResistors = puType::up;
  encoder.attachFullQuad(ENC_A_PIN, ENC_B_PIN);
  encoder.clearCount();
}
// 前回からのクリック数を返す(正:右回し/負:左回し。向きが逆ならENC_A_PINとENC_B_PINを入れ替える)
int encoderReadDetents()
{
  static int64_t lastCount = 0;
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

Notices in the files:
parts and their libraries:
© Hinata 2026
